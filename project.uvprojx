# Keil uVision project project.uvprojx, settings and files
target Main (5060960::V5.06 update 7 (build 960)::.\Compiler5)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --no-multibyte-chars
  c include: .\1-library;.\2-start;.\3-main;.\4-ware\Basic;.\4-ware\RTOS_Task;.\4-ware\Fatfs;.\4-ware\Flash;.\4-ware\FreeRTOS;.\4-ware\LVGL\bsp;.\4-ware\LVGL\core;.\4-ware\LVGL\draw;.\4-ware\LVGL\extra;.\4-ware\LVGL\font;.\4-ware\LVGL\gpu;.\4-ware\LVGL\hal;.\4-ware\LCD;.\4-ware\LVGL\misc;.\4-ware\LVGL\widgets;.\4-ware\RTC_Clock;.\4-ware\Sys_Config;.\4-ware\TFCard;.\4-ware\Music;.\4-ware\Music_lib\AAC;.\4-ware\Music_lib\APE;.\4-ware\Music_lib\FLAC;.\4-ware\Music_lib\MP3;.\4-ware\Cherry_USB\common;.\4-ware\Cherry_USB\core;.\4-ware\Cherry_USB\user;.\4-ware\Cherry_USB\class\audio;.\4-ware\Cherry_USB\class\cdc;.\4-ware\Cherry_USB\class\hid;.\4-ware\Cherry_USB\class\hub;.\4-ware\Cherry_USB\class\msc;.\4-ware\Cherry_USB\class\serial;.\4-ware\GUI_Icons;.\4-ware\GUI_Unit;.\4-ware\GUI_Page;.\4-ware\RingBuffer;.\4-ware\TLSF_Arena;.\4-ware\FlashDB;.\4-ware\Cherry_USB\class\vendor\display;.\4-ware\UF2;.\4-ware\Cherry_USB\class\gamepad;.\4-ware\Debug_Log;.\4-ware\PinYin;.\4-ware\Video;.\4-ware\NES;.\4-ware\Picture;.\4-ware\Text
  memory RVCT4: ROM 0x8010000 size 0xf0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group library
    ./1-library/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group start
    ./2-start/: core_cm4.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h startup_stm32f40_41xxx.s arm_cortexM4lf_math.lib arm_common_tables.h arm_const_structs.h arm_math.h core_cmFunc.h core_cmInstr.h core_cmSimd.h
  group main
    ./3-main/: main.c main.h stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h defines.h variables.c variables.h
  group basic
    ./4-ware/basic/: pin_ctrl.c pin_ctrl.h key.c key.h adc.c adc.h
    ./4-ware/Basic/: v2p_bat.c v2p_bat.h
  group sys_config
    ./4-ware/Sys_Config/: nvic_conf.c nvic_conf.h systick_conf.c systick_conf.h rng.c rng.h iwdg.c iwdg.h cpu_usage.c cpu_usage.h
  group rtos_task
    ./4-ware/RTOS_Task/: task_manager.c task_manager.h basic_task.c lvgl_task.c music_task.c usb_task.c game_task.c video_task.c
  group rtc_clock
    ./4-ware/RTC_Clock/: rtc_clock.c rtc_clock.h lunar.c lunar.h
  group lcd
    ./4-ware/LCD/: lcd_bsp.c lcd_bsp.h lcd_pwm.c lcd_pwm.h
  group freertos
    ./4-ware/freertos/: port.c list.c queue.c tasks.c atomic.h croutine.c croutine.h deprecated_definitions.h event_groups.c event_groups.h FreeRTOS.h FreeRTOSConfig.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h portmacro.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.c stream_buffer.h task.h rtos_timer.c rtos_timer.h
    ./4-ware/FreeRTOS/: timers.c timers.h
  group flash
    ./4-ware/Flash/: w25q128.c w25q128.h
  group flashdb
    ./4-ware/FlashDB/: fal.c fal.h fdb.c fdb_cfg.h fdb_def.h fdb_file.c fdb_kvdb.c fdb_low_lvl.h fdb_tsdb.c fdb_utils.c flashdb.h
  group tf_card
    ./4-ware/TFCard/: sdio_sdcard.c sdio_sdcard.h
  group fatfs
    ./4-ware/Fatfs/: diskio.c diskio.h fatfs.c fatfs.h ff.c ff.h ffconf.h ffunicode.c ffsystem.c
  group tlsf_arena
    ./4-ware/TLSF_Arena/: malloc.c malloc.h tlsf.c tlsf.h
  group debug_log
    ./4-ware/Debug_Log/: tsdb_log.c tsdb_log.h debug.c debug.h
  group pinyin
    ./4-ware/PinYin/: pinyin_dict.c pinyin_dict.h pinyin_find.c pinyin_find.h
  group video
    ./4-ware/Video/: video.c video.h mjpeg.c mjpeg.h
  group picture
    ./4-ware/Picture/: jpg.c jpg.h gif.c gif.h png.c png.h bmp.c bmp.h tjpgd.c tjpgd.h AnimatedGIF.c AnimatedGIF.h infback.c inffast.c inffast.h inffixed.h inflate.c inflate.h inftrees.c inftrees.h PNGdec.c PNGdec.h zconf.h zlib.h zutil.c zutil.h adler32.c
  group nes
    ./4-ware/NES/: nes_main.c nes_main.h nes_mapper.c nes_mapper.h nes_ppu.c nes_ppu.h 6502.s 6502mac.s cart.s equates.s nes_apu.c nes_apu.h
  group text
    ./4-ware/Text/: txt.c txt.h program.c program.h lrc.c lrc.h
  group gui_page
    ./4-ware/GUI_Page/: page_manager.c page_manager.h start_page.c start_page.h desktop_page.c desktop_page.h music_page.c music_page.h mem_monitor_page.c mem_monitor_page.h key_test_page.c key_test_page.h debug_page.c debug_page.h log_ctrl_page.c log_ctrl_page.h usb_page.c usb_page.h note_page.c note_page.h file_page.c file_page.h settings_page.c settings_page.h text_page.c text_page.h canvas_page.c canvas_page.h
  group gui_unit
    ./4-ware/GUI_Unit/: navigation_bar.c navigation_bar.h status_bar.c status_bar.h desktop_unit.c desktop_unit.h mem_unit.c mem_unit.h key_test_unit.c key_test_unit.h icon_unit.c icon_unit.h music_unit.c music_unit.h debug_unit.c debug_unit.h log_ctrl_unit.c log_ctrl_unit.h usb_ctrl_unit.c usb_ctrl_unit.h control_center.c control_center.h keyboard.c keyboard.h note_unit.c note_unit.h file_unit.c file_unit.h start_unit.c start_unit.h settings_unit.c settings_unit.h text_unit.c text_unit.h canvas_unit.c canvas_unit.h
  group gui_icons
    ./4-ware/GUI_Icons/: saving_icon.c headphone_icon.c usb_icon.c volume_icon.c card_icon.c muse_cube_icon.c close_icon.c exit_icon.c minimize_icon.c music_cycle.c music_exit.c music_like.c music_menu.c music_next.c music_order.c music_playing.c music_random.c music_suspend.c music_before.c file_icon.c pic_top.c pic_back.c app_clock.c app_drawing.c app_file_manager.c app_game.c app_music.c app_setting.c app_task_manager.c app_usb.c app_note.c app_video.c canvas_icon.c control_center_icon.c
  group lvgl_bsp
    ./4-ware/lvgl/bsp/: lv_api_map.h lv_conf.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h lv_port_disp.c lv_port_disp.h lv_port_indev.c lv_port_indev.h
  group lvgl_core
    ./4-ware/lvgl/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl_draw
    ./4-ware/lvgl/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl_extra
    ./4-ware/lvgl/extra/: lv_animimg.c lv_animimg.h lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h lv_chart.c lv_chart.h lv_colorwheel.c lv_colorwheel.h lv_extra.c lv_extra.h lv_flex.c lv_flex.h lv_grid.c lv_grid.h lv_gridnav.c lv_gridnav.h lv_imgbtn.c lv_imgbtn.h lv_keyboard.c lv_keyboard.h lv_layouts.h lv_led.c lv_led.h lv_libs.h lv_list.c lv_list.h lv_menu.c lv_menu.h lv_meter.c lv_meter.h lv_monkey.c lv_monkey.h lv_msgbox.c lv_msgbox.h lv_others.h lv_snapshot.c lv_snapshot.h lv_span.c lv_span.h lv_spinbox.c lv_spinbox.h lv_spinner.c lv_spinner.h lv_tabview.c lv_tabview.h lv_theme_basic.c lv_theme_basic.h lv_theme_default.c lv_theme_default.h lv_theme_mono.c lv_theme_mono.h lv_themes.h lv_tileview.c lv_tileview.h lv_widgets.h lv_win.c lv_win.h lv_bmp.c lv_bmp.h lv_fs_fatfs.c lv_fsdrv.h
  group lvgl_font
    ./4-ware/lvgl/font/: lv_font.c lv_font.h lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_symbol_def.h
    ./4-ware/LVGL/font/: fontupd.c fontupd.h Font8.c Font12.c Font16.c Font24.c lv_font_8.c lv_font_12.c lv_font_16.c lv_font_24.c lv_font_40.c lv_font_56.c lv_font_montserrat_12.c lv_font_unscii_8.c lv_font_unscii_16.c
  group lvgl_gpu
    ./4-ware/lvgl/gpu/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl_hal
    ./4-ware/lvgl/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl_misc
    ./4-ware/lvgl/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl_widgets
    ./4-ware/lvgl/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group music
    ./4-ware/Music/: music.c music.h i2s.c i2s.h es9018k2m.c es9018k2m.h wav.c wav.h aac.c aac.h ape.c ape.h flac.c flac.h mp3.c mp3.h max98357A.c max98357A.h spectrum_dsp.c spectrum_dsp.h
  group music_lib_aac
    ./4-ware/Music_lib/AAC/: aacassembly.h aacbitstream.c aacbitstream.h aacbuffers.c aaccoder.h aaccommon.h aacdct4.c aacdec.c aacdec.h aacdecelmnt.c aacdequant.c aacfft.c aacfilefmt.c aachuffman.c aachufftabs.c aacimdct.c aacnoiseless.c aacpns.c aacsbr.c aacsbr.h aacsbrfft.c aacsbrfreq.c aacsbrhfadj.c aacsbrhfgen.c aacsbrhuff.c aacsbrimdct.c aacsbrmath.c aacsbrqmf.c aacsbrside.c aacsbrtabs.c aacstatname.h aacstproc.c aactabs.c aactns.c aactrigtabs.c aactrigtabs_fltgen.c sbrcov.s sbrqmfak.s sbrqmfsk.s
  group music_lib_flac
    ./4-ware/Music_lib/FLAC/: foxen-flac.c foxen-flac.h
  group music_lib_mp3
    ./4-ware/Music_lib/MP3/: asmmisc_rvds.s asmpoly_thumb2_rvds.s assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3common.h mp3dec.c mp3dec.h mp3tabs.c mpadecobjfixpt.h scalfact.c statname.h stproc.c subband.c trigtabs.c
  group music_lib_ape
    ./4-ware/Music_lib/APE/: apedecoder.c apedecoder.h demac_config.h entropy.c entropy.h filter_16_11.c filter_32_10.c filter_64_11.c parser.c parser.h predictor.c predictor.h predictor-arm.S vector_math_generic.h
  group usb_user
    ./4-ware/Cherry_USB/user/: usbd_cdc_conf.c usbd_cdc_conf.h usbd_msc_conf.c usbd_msc_conf.h usbd_uac1_conf.c usbd_uac1_conf.h usbd_uac2_conf.c usbd_uac2_conf.h usbd_display_conf.c usbd_display_conf.h usbd_hid_conf.c usbd_hid_conf.h usbh_msc_conf.c usbh_msc_conf.h usbh_hid_conf.c usbh_hid_conf.h usbh_serial_conf.c usbh_serial_conf.h
  group usb_lib_core
    ./4-ware/Cherry_USB/core/: usb_config.h usb_glue_st.c usb_osal_freertos.c usbd_core.c usbd_core.h usbh_core.c usbh_core.h usb_dc_dwc2.c usb_dwc2_param.h usb_dwc2_reg.h usb_hc_dwc2.c
  group usb_lib_common
    ./4-ware/Cherry_USB/common/: usb_dc.h usb_dcache.h usb_def.h usb_errno.h usb_hc.h usb_list.h usb_log.h usb_memcpy.h usb_mempool.h usb_osal.h usb_otg.h usb_ringbuffer.h usb_util.h usb_version.h
  group usb_lib_msc
    ./4-ware/Cherry_USB/class/msc/: usb_msc.h usb_scsi.h usbd_msc.c usbd_msc.h usbh_msc.c usbh_msc.h usbh_fatfs.c usbh_fatfs.h
  group usb_lib_cdc
    ./4-ware/Cherry_USB/class/cdc/: usb_cdc.h usbd_cdc.h usbd_cdc_acm.c usbd_cdc_acm.h
  group usb_lib_audio
    ./4-ware/Cherry_USB/class/audio/: usb_audio.h usbd_audio.c usbd_audio.h
  group usb_lib_hub
    ./4-ware/Cherry_USB/class/hub/: usb_hub.h usbh_hub.c usbh_hub.h
  group usb_lib_hid
    ./4-ware/Cherry_USB/class/hid/: usb_hid.h usbd_hid.c usbd_hid.h usbh_hid.c usbh_hid.h
  group usb_lib_display
    ./4-ware/Cherry_USB/class/vendor/display/: usbd_display.c usbd_display.h
  group usb_lib_gamepad
    ./4-ware/Cherry_USB/class/gamepad/: usb_gamepad.h usbd_gamepad.c usbd_gamepad.h
  group usb_lib_serial
    ./4-ware/Cherry_USB/class/serial/: usbh_cdc_acm.c usbh_cdc_acm.h usbh_ch34x.c usbh_ch34x.h usbh_cp210x.c usbh_cp210x.h usbh_ftdi.c usbh_ftdi.h usbh_gsm.c usbh_pl2303.c usbh_pl2303.h usbh_serial.c usbh_serial.h
