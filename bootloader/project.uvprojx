# Keil uVision project project.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\Compiler5)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_USB_OTG_FS,STM32F40_41xxx
  c misc: --no-multibyte-chars
  c include: .\1-library;.\2-start;.\3-main;.\4-ware;.\5-freertos;.\6-cherryusb
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group library
    ./1-library/: misc.c misc.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_tim.c stm32f4xx_tim.h
  group start
    ./2-start/: core_cm4.h stm32f4xx.h system_stm32f4xx.c system_stm32f4xx.h startup_stm32f40_41xxx.s
  group main
    ./3-main/: bootloader.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group ware
    ./4-ware/: bootuf2.c bootuf2.h bootuf2_config.h chip_rom.c chip_rom.h key.c key.h lcd_bsp.c lcd_bsp.h malloc.c malloc.h nvic_conf.c nvic_conf.h pin_ctrl.c pin_ctrl.h systick_conf.c systick_conf.h tlsf.c tlsf.h
  group freertos
    ./5-freertos/: FreeRTOS.h FreeRTOSConfig.h list.c list.h mpu_wrappers.h port.c portable.h portmacro.h projdefs.h queue.c queue.h semphr.h stack_macros.h task.h tasks.c timers.c timers.h
  group cherryusb
    ./6-cherryusb/: usb_config.h usb_dc.h usb_dc_dwc2.c usb_dcache.h usb_def.h usb_dwc2_param.h usb_dwc2_reg.h usb_errno.h usb_glue_st.c usb_list.h usb_log.h usb_memcpy.h usb_msc.h usb_osal.h usb_osal_freertos.c usb_scsi.h usb_util.h usbd_core.c usbd_core.h usbd_msc.c usbd_msc.h usbd_msc_conf.c usbd_msc_conf.h
